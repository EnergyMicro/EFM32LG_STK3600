# IAR project blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32LG990F256 EnergyMicro EFM32LG990F256
  ICCARM.CCDefines: EFM32LG990F256; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\EnergyMicro\EFM32LG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\bsp; ..\..\..\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: blink.bin
  ILINK.IlinkOutputFile: blink.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32LG990F256.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32LG990F256; DEBUG_EFM
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32LG/Source/IAR/: startup_efm32lg.s
    ../../../../../Device/EnergyMicro/EFM32LG/Source/: system_efm32lg.c
  group bsp
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_system.c em_usart.c
  group Source
    ../: blink.c
